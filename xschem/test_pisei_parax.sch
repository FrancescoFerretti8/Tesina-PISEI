v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -20 290 0 0 {name=p1 lab=A0}
C {devices/ipin.sym} -20 340 0 0 {name=p5 lab=A1}
C {devices/ipin.sym} -20 100 0 0 {name=p3 lab=VDD}
C {devices/ipin.sym} -20 130 0 0 {name=p4 lab=VSS}
C {devices/opin.sym} 400 160 0 0 {name=p2 lab=out}
C {devices/ipin.sym} -20 190 0 0 {name=p6 lab=a}
C {devices/ipin.sym} -20 230 0 0 {name=p7 lab=b}
