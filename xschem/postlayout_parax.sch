v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -470 310 0 0 {name=p1 lab=A0}
C {devices/ipin.sym} -470 360 0 0 {name=p5 lab=A1}
C {devices/ipin.sym} -470 120 0 0 {name=p3 lab=VDD}
C {devices/ipin.sym} -470 150 0 0 {name=p4 lab=VSS}
C {devices/opin.sym} -50 180 0 0 {name=p2 lab=out}
C {devices/ipin.sym} -470 210 0 0 {name=p6 lab=a}
C {devices/ipin.sym} -470 250 0 0 {name=p7 lab=b}
