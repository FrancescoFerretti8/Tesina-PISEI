v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {pass_gate_b.sym} -50 -40 0 0 {name=x1}
